# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89F0541 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Application;.\Board;.\Core;.\Drivers
  link misc: REMOVEUNUSED
  group Application
    ./Application/: userdef.h main.c
  group Core
    ./Core/: hc89f0541_delay.c hc89f0541_uart.c
  group Drivers
    ./Drivers/: STARTUP.A51 HC_DEFINE.h HC89F0541.H
